## Kconfig
```kconfig
config MY_DRIVER
	tristate "IT'S SO FUNNY"
	help
	  This is my TROJAN, go install this sh*t
```
